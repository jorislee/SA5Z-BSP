# Keil uVision project flashDB.uvprojx, settings and files
target flashDB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: xa5z-30-flashDB +hex
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L -c -d -e -s --output flashDB.lst
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --bin -o flashDB.bin
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\bsp;..\sa5z-30;..\..\..\components\cm3\CMSIS\Core\Include;..\..\..\components\cm3\CMSIS\Device\Include;..\..\..\components\cm3\CMSIS\Device\StdPeriph_Driver\inc;..\..\..\components\common;..\..\..\components\FreeRTOS-Kernel\include;..\..\..\components\FreeRTOS-Kernel\portable\RVDS\ARM_CM3;..\..\..\components\gmssl\include;..\..\..\components\FlashDB\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x18000
  memory RVCT9: RAM 0x18000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group startup
    ../../../components/cm3/CMSIS/Device/Source/ARM/: startup_CM3DS.s
  group src
    ./: main.c
  group freertos
    ../../../components/FreeRTOS-Kernel/: timers.c tasks.c stream_buffer.c queue.c list.c event_groups.c
    ../../../components/FreeRTOS-Kernel/portable/MemMang/: heap_5.c
    ../../../components/FreeRTOS-Kernel/portable/RVDS/ARM_CM3/: port.c
  group cmsis
    ../../../components/cm3/CMSIS/Device/StdPeriph_Driver/src/: CM3DS_dma.c CM3DS_gpio.c CM3DS_watchdog.c CM3DS_uart.c CM3DS_timer.c CM3DS_spi.c CM3DS_rcc.c CM3DS_i2c.c
    ../../../components/cm3/CMSIS/Device/Source/: system_CM3DS.c
  group bsp
    ../../../bsp/: xs_flash.c xs_uart.c
  group com
    ../../../components/common/: err.c log.c log_buffers.c
  group flashDB
    ../../../components/FlashDB/src/: fdb_utils.c fdb_tsdb.c fdb_kvdb.c fdb.c fdb_file.c
    ../../../components/FlashDB/samples/: kvdb_basic_sample.c kvdb_type_blob_sample.c kvdb_type_string_sample.c
    ./: fal.c
